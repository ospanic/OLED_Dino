# Keil uVision project dino.uvproj, settings and files
target Dino (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: template +hex
  c flags: Optimize=8 SizeSpeed=1
  group App
    ./: main.c I2C.c OLED.c dino.c Teris.c
